FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-SERVICE-add-files-from-qemu_src.patch file://0002-hw-misc-meson.build-add-msi-example.patch"

