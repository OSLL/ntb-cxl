FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Patch-for-pingpong-demo-for-v7.patch"
